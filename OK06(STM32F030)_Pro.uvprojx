# Keil uVision project OK06(STM32F030)_Pro.uvprojx, settings and files
target OK06 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: OK06(STM32F030)_Pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: .\Libraries\CMSIS\Include;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\User\inc;.\Libraries\CMSIS\Device;.\Application\app_inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./Libraries/CMSIS/Include/: system_stm32f0xx.c
    ./Libraries/CMSIS/Device/: startup_stm32f030x8.s
  group Libraires
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ./User/src/: main.c Sys.c Gpio.c Adc.c Timer.c Uart.c M24C16.c IIC.c
  group Application
    ./Application/app_src/: comm_uart.c variables.c storage.c a_control_sol.c a_deta_exchange.c a_lock_mode.c access_flash.c anjou_test.c call_mode_process.c encoder.c ecu_test.c initial.c key_input.c mode_process.c motion_command.c overload.c select_mode.c select_signal.c state_table_1_0.c trq_adjust_trqchange.c tst_break.c
    ./Application/app_inc/: comm_uart.h comm_uart_local.h def_local.h constants.h variables.h storage.h a_data_exchange.h version.h flash_data_read.h input_encoder.h functions.h tst_break.h access_flash.h anjou_test.h ecu_test.h trq_adjust_trqchange.h a_common_value.h mode_process.h motion_com.h select_mode.h
